# Keil uVision project demo_ov2640_dma.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_ov2640_dma
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Core;.\System;.\Peripheral;.\Module;.\CMSIS\Core;.\CMSIS\Device;.\CMSIS\Device\startup;.\SPL\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.c stm32f10x_conf.h stm32f10x_it.c
  group System
    ./System/: delay.c
  group Module
    ./Module/: oled.c oled_font.c sht30.c ov2640.c ov2640_cfg.c
  group Peripheral
    ./Peripheral/: i2c.c sccb.c uart.c
  group CMSIS/Core
    ./CMSIS/Core/: core_cm3.c
  group CMSIS/Device
    ./CMSIS/Device/: stm32f10x.h system_stm32f10x.c
  group CMSIS/Device/startup
    ./CMSIS/Device/startup/: startup_stm32f10x_md.s
  group SPL
    ./SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
